# Keil uVision project LCD_1768_3.2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: test +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Source\Lcd;..\Source\I2C
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group User
    ../Source/User/: main.c
  group Lcd
    ../Source/Lcd/: Lcd.c LCD_touch.C
  group Documentation
    ../: Readme.txt
  group I2C
    ../Source/I2C/: i2c.c
  group code
    ../Source/User/: recognize.c bayes.c
  group uart
    ../Source/User/: uart.c Retarget.c
  group Startup code
    ../LPC17xx/: startup_LPC17xx.s system_LPC17xx.c
